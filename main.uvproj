# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib;.\user\inc
  group src
    ./user/src/: main.c mainproc.c timer.c uart.c watermark.c wdg.c event.c
  group inc
    ./user/inc/: config.h event.h mainproc.h timer.h type.h uart.h watermark.h wdg.h
  group lib
    ./lib/: stc8.h
